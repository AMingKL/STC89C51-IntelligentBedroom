# Keil uVision project IntelligentBedroom.uvproj, settings and files
target IntelligentBedroom (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: IntelligentBedroom +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\users
  group user
    ./users/: main.c ds1302.c lcd.c pwm.c Delay.c dht11.c ledbeep.c key.c usart.c
  group doc
    ./users/: bsp_xx.c bsp_xx.h read me.txt
